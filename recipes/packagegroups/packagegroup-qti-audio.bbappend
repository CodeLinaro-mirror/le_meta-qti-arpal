RDEPENDS:packagegroup-qti-audio += ' \
    qal \
    qal-headers \
'
